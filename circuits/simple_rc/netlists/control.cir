.control
* Timestamp: Sat Feb  3 23:03:43 2024
set wr_singlescale  $ makes one x-axis for wrdata
set wr_vecnames     $ puts names at top of columns
listing
op
print line in mid > /workspaces/sw_pwr_book_sim/circuits/simple_rc/sim_results/op1.txt
tran 1e-3 20e-3
wrdata /workspaces/sw_pwr_book_sim/circuits/simple_rc/sim_results/tr1.txt in mid
quit
.endc
