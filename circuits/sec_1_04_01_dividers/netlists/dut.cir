r1 in out2 140
r2 in out1 132
rload1 out2 out2_com 100
rload2 out1 out1_com 50
